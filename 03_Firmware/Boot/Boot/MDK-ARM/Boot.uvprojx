# Keil uVision project Boot.uvprojx, settings and files
target STM32F4x1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Boot +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F411xE
  c include: ..\Core\Inc;..\Drivers\STM32F4xx_StdPeriph_Driver\inc;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\SYSTEM\RTT;..\SYSTEM\easylogger\inc;..\Tasks\Ymodem;..\Tasks\Common;..\Middlewares\AES
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Core
    ../Core/Src/: main.c stm32f4xx_it.c system_stm32f4xx.c tim.c Gpio.c Usart.c Flash.c
    ../Core/: startup_stm32f411xe.s
  group Drivers
    ../Drivers/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_flash.c
  group Middlewares
    ../Middlewares/AES/: AES.c
  group SYSTEM
    ../SYSTEM/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
    ../SYSTEM/easylogger/src/: elog.c elog_async.c elog_buf.c elog_utils.c
    ../SYSTEM/easylogger/port/: elog_port.c
  group Tasks
    ../Tasks/Ymodem/: ymodem.c
    ../Tasks/Common/: common.c
